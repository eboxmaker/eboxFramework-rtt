# Keil uVision project stm32f0x.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ebox +hex
  c flags: Optim=1 OneElfS=1 wLevel=1
  c define: USE_FULL_LL_DRIVER,STM32F030x8
  c include: ..\..\..\mcuLib\stm32f0xx\Libraries\CMSIS\Include;..\..\..\mcuLib\stm32f0xx\Libraries\STM32F0xx_HAL_Driver\Inc;..\..\..\mcuLib\stm32f0xx\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\ebox\core;..\..\..\ebox\core\LinkedList;..\..\..\ebox\hardware\cortex-m0;..\..\..\ebox\hardware\cortex-m0\Peripherals;..\..\..\ebox\interface;..\..\..\ebox\interface\spi;..\..\..\ebox\interface\i2c;..\..\..\ebox\interface\event;..\..\..\user;..\..\..\user\board\Nucleo_f0;..\..\..\component\edriver;..\..\..\ebox\hardware\cortex-m0\mcu;..\..\..\component\modbus\libraries\Modbus;..\..\..\component\modbus\libraries\ModbusSerial;..\..\..\component\gui;..\..\..\component\apps
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group start_code
    ../../../mcuLib/stm32f0xx/Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f072xb.s startup_stm32f030x8.s
  group CMSIS
    ../../../mcuLib/stm32f0xx/Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group libraries_LL
    ../../../mcuLib/stm32f0xx/Libraries/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_utils.c stm32f0xx_ll_rcc.c stm32f0xx_ll_gpio.c stm32f0xx_ll_exti.c stm32f0xx_ll_usart.c stm32f0xx_ll_dma.c stm32f0xx_ll_adc.c stm32f0xx_ll_tim.c
  group ebox_core
    ../../../ebox/core/: ebox_core.cpp ebox_init.cpp big_little.c crc.c ebox_mem.c fifo.c itoa.c myprintf.c Dstring.cpp IPAddress.cpp new.cpp print.cpp ringbuf.cpp sort.cpp Stream.cpp WString.cpp
  group interface
    ../../../ebox/interface/DateTime/: DateTime.cpp basicRtc.cpp RtcMillis.cpp
    ../../../ebox/interface/spi/: soft_spi.cpp
    ../../../ebox/interface/i2c/: soft_i2c.cpp i2c.cpp
    ../../../ebox/interface/event/: EventVar.cpp
    ../../../ebox/interface/: hmi.cpp
  group ebox_mcu
    ../../../ebox/hardware/cortex-m0/: mcu.cpp rcc.cpp nvic.cpp dma.cpp object.cpp ebox_it.cpp
    ../../../user/board/Nucleo_f0/: mcu_config.h
    ../../../ebox/hardware/cortex-m0/Peripherals/: ebox_gpio.cpp ebox_uart.cpp ebox_exti.cpp ebox_i2c.cpp ebox_adc.cpp ebox_wdg.cpp ebox_iflash.cpp ebox_timer.cpp ebox_pwm.cpp ebox_in_capture.cpp ebox_spi.cpp ebox_rtc.cpp
  group gui
    ../../../component/gui/: Font8_ASCII.cpp Font16_ASCII.cpp Font16_HZ.cpp Font24_ASCII.cpp Font32_ASCII.cpp FontCustom.cpp graphic.cpp gui_base.cpp gui_bitmap.cpp gui_button.cpp gui_list.cpp gui_menu.cpp gui_page.cpp gui_sidebar.cpp gui_text.cpp gui_textview.cpp
  group user
    ../../../user/: main.cpp
    ../../../user/board/Nucleo_f0/: bsp_ebox.cpp
    ../../../component/gui/example/: ui.cpp ui_main.cpp ui_menu.cpp ui_password.cpp ui_setValue.cpp
  group example
    ../../../example/3.pwm/: 1.pwm(F4).cpp pwm_f0.cpp
    ../../../example/5.uart/: 1.helloWorld.cpp 2.roll_back.cpp
    ../../../example/1.digital/: 1.gpio_write.cpp 4.parallel_gpio.cpp
    ../../../example/10.i2c/: 1.24c02.cpp
    ../../../example/2.analog/: 3.adc_read.cpp
    ../../../example/7.wdg/: 1.iwdg.cpp
    ../../../example/32.内部flash读写/: 2.flash_f4.cpp 2.flash_f04.cpp 1.flash_test.cpp
    ../../../example/6.timer/: 1.timer1.cpp 2.timer2.cpp 3.encoder.cpp
    ../../../example/11.in_capture/: 1.simple_event.cpp 2.complex_event.cpp 3.multi_complex_pulse.cpp
    ../../../example/9.spi/: 3.ltc1446.cpp
    ../../../example/12.定时器正交解码/: encode.cpp
    ../../../example/core/: core_cpuClock.cpp core_Systick.cpp core_SystickMultipe.cpp
    ../../../example/4.exti/: gpio_exti.cpp
    ../../../example/8.rtc/: rtc_calendar F0.cpp
    ../../../component/modbus/libraries/ModbusSerial/examples/: lamp.cpp
    ../../../example/20.display/: 8.9225_test.cpp
    ../../../example/16.gui/: main.cpp
  group 说明
    ../: 说明.txt
  group eDriver
    ../../../component/edriver/: LTC1446.cpp parallel_gpio.cpp TFT9225.cpp
    ../../../component/modbus/libraries/ModbusSerial/: ModbusSerial.cpp ModbusSerial.h
    ../../../component/modbus/libraries/Modbus/: Modbus.cpp Modbus.h
software components: CMSIS:CORE 5.5.0, RTOS:kernel 3.1.5
